# Keil uVision project backlight.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F1K08S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: backlight +hex
  c flags: Optimize=8 SizeSpeed=1
  asm include: .\mycode
  group mycode
    ./mycode/: main.c user.c time.c
